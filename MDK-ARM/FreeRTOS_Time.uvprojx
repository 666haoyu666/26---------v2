# Keil uVision project FreeRTOS_Time.uvprojx, settings and files
target FreeRTOS_Time (5060528::V5.06 update 5 (build 528)::ARMCC)
  device: STM32F411CEUx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.3.0.0
  cpu: IRAM(0x20000000-0x2001FFFF) IROM(0x8000000-0x807FFFF)  CLOCK(25000000) FPU2 CPUTYPE("Cortex-M4") TZ
  output: FreeRTOS_Time +hex
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=5 v6LangP=3 wLevel=2
  c define: USE_HAL_DRIVER,STM32F411xE
  c include: ../Core/Inc;../Drivers/STM32F4xx_HAL_Driver/Inc;../Drivers/STM32F4xx_HAL_Driver/Inc/Legacy;../Middlewares/Third_Party/FreeRTOS/Source/include;../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS_V2;../Middlewares/Third_Party/FreeRTOS/Source/portable/RVDS/ARM_CM4F;../Drivers/CMSIS/Device/ST/STM32F4xx/Include;../Drivers/CMSIS/Include;../01_App/app/app_init/platform_io_register;../01_App/app/app_init/user_task_config;../01_App/app/app_isr_handlers;../01_App/app/app_main;../01_App/app/app_tracking;../01_Service/service/service_diff_odom;../01_Service/service/service_diff_odom/platform/motor;../01_Service/service/service_diff_odom/platform/imu;../01_Service/service/service_track_ctrl;../02_Config;../02_Platform/platform_common;../02_Platform/platform_bsp/line_sensor/bsp_wrapper_line_sensor;../02_Platform/platform_bsp/line_sensor/bsp_adapter_port_line_sensor;../02_Platform/platform_bsp/motor/bsp_wrapper_motor;../02_Platform/platform_bsp/motor/bsp_adapter_port_motor;../02_Platform/platform_os/inc;../02_Platform/platform_os/os_wrapper/inc;../02_Platform/platform_os/os_implementation/freertos/inc;../02_Platform/platform_mcu/gpio/inc;../02_Platform/platform_mcu/pwm/inc;../02_Platform/platform_mcu/encoder/inc;../02_Platform/platform_mcu/timer/inc;../03_Bsp/bsp_line_sensor/Driver/Inc;../03_Bsp/bsp_motor/Driver/Inc;../03_Bsp/bsp_motor/handler/Inc;../03_Bsp/bsp_imu/inc;../02_Platform/platform_bsp/imu/bsp_wrapper_imu;../02_Platform/platform_bsp/imu/bsp_adapter_port_imu;../02_Platform/platform_mcu/usart/inc;../03_Middlewares/algorithm/pid;../99_Utils/common;../05_impl;../01_Service/service/service_track_ctrl/platform/imu_ctrl_port;../01_Service/service/service_track_ctrl/platform/motor_ctrl_port;../01_Service/service/service_track_ctrl/platform/track_port
  asm include: ../Core/Inc;../Drivers/STM32F4xx_HAL_Driver/Inc;../Drivers/STM32F4xx_HAL_Driver/Inc/Legacy;../Middlewares/Third_Party/FreeRTOS/Source/include;../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS_V2;../Middlewares/Third_Party/FreeRTOS/Source/portable/RVDS/ARM_CM4F;../Drivers/CMSIS/Device/ST/STM32F4xx/Include;../Drivers/CMSIS/Include
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x20000
  group 01_App/app
    ../01_App/app/app_init/platform_io_register/: user_periph_setup.c
    ../01_App/app/app_init/user_task_config/: user_task_reso_config.c
    ../01_App/app/app_isr_handlers/: user_isr_handlers.c
    ../01_App/app/app_main/: app_main.c
    ../01_App/app/app_tracking/: app_tracking_task.c
  group 01_Service/service
    ../01_Service/service/service_diff_odom/: service_diff_odom.c
    ../01_Service/service/service_track_ctrl/: service_track_ctrl.c
  group 01_Service/service/platform_ports
    ../01_Service/service/service_diff_odom/platform/motor/: motor_port.c
    ../01_Service/service/service_diff_odom/platform/imu/: imu_port.c
    ../01_Service/service/service_track_ctrl/platform/track_port/: track_port.c
    ../01_Service/service/service_track_ctrl/platform/imu_ctrl_port/: imu_ctrl_port.c
    ../01_Service/service/service_track_ctrl/platform/motor_ctrl_port/: motor_ctrl_port.c
  group 02_Platform/platform_bsp
    ../02_Platform/platform_bsp/line_sensor/bsp_wrapper_line_sensor/: bsp_wrapper_line_sensor.c
    ../02_Platform/platform_bsp/line_sensor/bsp_adapter_port_line_sensor/: bsp_adapter_port_line_sensor.c
    ../02_Platform/platform_bsp/motor/bsp_wrapper_motor/: bsp_wrapper_motor.c
    ../02_Platform/platform_bsp/motor/bsp_adapter_port_motor/: bsp_adapter_port_motor.c
    ../02_Platform/platform_bsp/imu/bsp_wrapper_imu/: bsp_wrapper_imu.c
    ../02_Platform/platform_bsp/imu/bsp_adapter_port_imu/: bsp_adapter_port_imu.c
  group 02_Platform/platform_os/os_wrapper
    ../02_Platform/platform_os/os_wrapper/src/: osal_heap.c osal_mutex.c osal_queue.c osal_sema.c osal_task.c osal_timer.c
  group 02_Platform/platform_os/os_implementation
    ../02_Platform/platform_os/os_implementation/freertos/src/: os_freertos_heap.c os_freertos_mutex.c os_freertos_queue.c os_freertos_sema.c os_freertos_task.c os_freertos_timer.c
  group 02_Platform/platform_mcu
    ../02_Platform/platform_mcu/gpio/src/: io_port.c
    ../02_Platform/platform_mcu/pwm/src/: pwm_port.c
    ../02_Platform/platform_mcu/encoder/src/: encoder_port.c
    ../02_Platform/platform_mcu/timer/src/: timer_port.c
    ../02_Platform/platform_mcu/usart/src/: usart_port.c
  group 03_Bsp
    ../03_Bsp/bsp_line_sensor/Driver/Src/: bsp_lsensor_driver.c
    ../03_Bsp/bsp_motor/Driver/Src/: bsp_motor_driver.c encoder_motor.c
    ../03_Bsp/bsp_motor/handler/Src/: bsp_motor_handler.c
    ../03_Bsp/bsp_imu/src/: wt_imu.c
  group 03_Middlewares/algorithm
    ../03_Middlewares/algorithm/pid/: pid.c
  group 99_Utils/common
    ../99_Utils/common/: myprintf.c
  group Application/MDK-ARM
    ./: startup_stm32f411xe.s
  group Application/User/Core
    ../Core/Src/: main.c gpio.c freertos.c adc.c dma.c i2c.c tim.c usart.c stm32f4xx_it.c stm32f4xx_hal_msp.c stm32f4xx_hal_timebase_tim.c
  group Drivers/STM32F4xx_HAL_Driver
    ../Drivers/STM32F4xx_HAL_Driver/Src/: stm32f4xx_hal_tim.c stm32f4xx_hal_tim_ex.c stm32f4xx_hal_adc.c stm32f4xx_hal_adc_ex.c stm32f4xx_ll_adc.c stm32f4xx_hal_rcc.c stm32f4xx_hal_rcc_ex.c stm32f4xx_hal_flash.c stm32f4xx_hal_flash_ex.c stm32f4xx_hal_flash_ramfunc.c stm32f4xx_hal_gpio.c stm32f4xx_hal_dma_ex.c stm32f4xx_hal_dma.c stm32f4xx_hal_pwr.c stm32f4xx_hal_pwr_ex.c stm32f4xx_hal_cortex.c stm32f4xx_hal.c stm32f4xx_hal_exti.c stm32f4xx_hal_i2c.c stm32f4xx_hal_i2c_ex.c stm32f4xx_hal_uart.c
  group Drivers/CMSIS
    ../Core/Src/: system_stm32f4xx.c
  group Middlewares/FreeRTOS
    ../Middlewares/Third_Party/FreeRTOS/Source/: croutine.c event_groups.c list.c queue.c stream_buffer.c tasks.c timers.c
    ../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS_V2/: cmsis_os2.c
    ../Middlewares/Third_Party/FreeRTOS/Source/portable/MemMang/: heap_4.c
    ../Middlewares/Third_Party/FreeRTOS/Source/portable/RVDS/ARM_CM4F/: port.c
software components: CMSIS:CORE 4.3.0
